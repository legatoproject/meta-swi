RDEPENDS:${PN} += "libopencore-amr-dev"
RDEPENDS:${PN} += "libvo-amrwbenc-dev"
