RDEPENDS:${PN} += "system-core-adbd"
