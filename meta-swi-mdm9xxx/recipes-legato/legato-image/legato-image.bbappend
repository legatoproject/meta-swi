DEPENDS += "cwetool-native"
