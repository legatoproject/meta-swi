# Add additional packages here
# IMAGE_INSTALL_append += "whatever-package"

# You can also remove packages
# IMAGE_INSTALL_remove = "whatever-package"
