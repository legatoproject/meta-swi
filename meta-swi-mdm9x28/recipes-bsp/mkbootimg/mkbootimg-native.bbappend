
# Tag LE.BR.1.2.1-64400-9x07
SRCREV = "6ba4d991ead9291ab151a60515304405d30724e5"
SYSTEMCORE_REPO = "git://codeaurora.org/platform/system/core;branch=mdm"
