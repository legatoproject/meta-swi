FILESEXTRAPATHS_prepend := "${THISDIR}/iptables:"

SRC_URI += "file://0003-extensions-libxt_bpf-Fix-build-with-old-kernel-versions.patch"
