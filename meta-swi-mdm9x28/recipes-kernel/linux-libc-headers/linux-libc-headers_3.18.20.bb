KORG_ARCHIVE_COMPRESSION = "xz"

require recipes-kernel/linux-libc-headers/linux-libc-headers.inc

SRC_URI[md5sum] = "952c9159acdf4efbc96e08a27109d994"
SRC_URI[sha256sum] = "0d795f28cba56ba7fb1ccb4552dd7b0804957e23c9cab14b92166b1a5f4f95d7"

