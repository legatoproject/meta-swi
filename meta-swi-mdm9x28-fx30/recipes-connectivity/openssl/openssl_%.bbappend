RPROVIDES:${PN} += "libcrypto"
