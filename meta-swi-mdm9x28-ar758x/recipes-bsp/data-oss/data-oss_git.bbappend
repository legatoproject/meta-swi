
# Tag LE.UM.1.2-15100-9x07
SRCREV_swi-mdm9x28-ar758x = "0e5131ffe61c3d134b75993c2845d84a62d9e8c9"
DATAOSS_REPO = "git://codeaurora.org/platform/vendor/qcom-opensource/dataservices;branch=data.lnx.1.0.c8-rel"
