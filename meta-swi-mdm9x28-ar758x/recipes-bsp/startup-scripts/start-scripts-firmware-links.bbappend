
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI ="file://firmware-links.sh"
