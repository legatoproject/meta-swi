
# Tag LE.UM.1.2-15100-9x07
SRCREV = "0b48df4f4ecfeec1013ad123dae136cb3bbbf983"
DTBTOOL_NATIVE_REPO = "git://codeaurora.org/device/qcom/common;branch=le-blast.lnx.1.1.c2-rel"
