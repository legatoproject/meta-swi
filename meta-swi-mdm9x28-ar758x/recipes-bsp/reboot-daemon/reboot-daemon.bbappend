
# Tag LE.UM.1.2-15100-9x07
SRCREV = "ef84bd5b948563d06e9da2000155c505a70cf875"
REBOOTD_REPO = "git://codeaurora.org/quic/le/mdm/reboot-daemon;branch=mdm-ss-mgr.lnx.1.0.c4-rel"
