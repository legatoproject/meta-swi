PR = "r2"

# Start adb after iSerial is set.
SRC_URI += "file://0002-Fix-usb-serial-conflict.patch"
