# On ar758x, the IMA key is shipped with the kernel.
IMA_INCLUDE_KERNEL_KEY = "true"
