# Look at this directlry first.
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
