IMAGE_INSTALL_append = " system-core-adbd"
