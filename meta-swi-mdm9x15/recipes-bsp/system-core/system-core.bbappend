FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://composition-sierra"
SRC_URI += "file://0001-QTI9X1555-1313-Do-not-change-ADB-device-ID.patch"
