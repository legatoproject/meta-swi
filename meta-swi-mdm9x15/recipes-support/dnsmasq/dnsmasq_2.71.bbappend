INITSCRIPT_PARAMS = "start 95 S . stop 80 S ."
