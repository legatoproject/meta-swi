INITSCRIPT_PARAMS = "start 20 S . stop 80 S ."
