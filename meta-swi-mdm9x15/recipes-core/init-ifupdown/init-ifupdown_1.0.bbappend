# Look at this directlry first.
FILESEXTRAPATHS_append := "${THISDIR}/files:"

SRC_URI_append += "file://interfaces"
