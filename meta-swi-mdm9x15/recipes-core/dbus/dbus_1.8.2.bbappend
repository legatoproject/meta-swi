INITSCRIPT_PARAMS = "start 03 S . stop 97 S ."
