do_install_append() {
    rm -f ${D}/${sysconfdir}/init.d/dbus-1
}

