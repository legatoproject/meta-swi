# Remove powertop package. It conflicts with ti-compat-wireless about libnls
PROFILETOOLS = "\
    oprofile \
    oprofileui-server \
    latencytop \
    "
