
RDEPENDS_${PN} += "libopencore-amr-dev"

