FILESEXTRAPATHS_prepend := "${THISDIR}/${P}:"

SRC_URI += "file://0001-Don-t-change-console-attributes.patch"
