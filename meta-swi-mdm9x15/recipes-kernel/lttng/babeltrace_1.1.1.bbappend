FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

#use latest commit ( post 1.2.0 ) to work with lttng-tools 2.5 

SRCREV = "51685e5daa36c809c4a93b9992575dd27bb3f2a5"

