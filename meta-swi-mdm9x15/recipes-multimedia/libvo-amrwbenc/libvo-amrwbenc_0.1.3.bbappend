EXTRA_OECONF = " \
    --enable-armv7neon \
"
