FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += " file://compile-elfutils-with-gcc-6.2.patch"
