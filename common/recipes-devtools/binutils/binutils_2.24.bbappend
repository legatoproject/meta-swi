do_compile_prepend() {
  export ERROR_ON_WARNING=no
}
