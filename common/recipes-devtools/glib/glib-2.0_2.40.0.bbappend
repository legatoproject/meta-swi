FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += " file://compile-glib2-with-gcc-6.2.patch"
