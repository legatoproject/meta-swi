FILESEXTRAPATHS_prepend := "${THISDIR}/files"

SRC_URI += "file://qemu-CVE-2015-3456.patch \
"
