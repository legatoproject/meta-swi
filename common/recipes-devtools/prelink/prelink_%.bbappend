FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://glob-glibc-symver.patch"
