FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://gnu-inline-gperf-table-problem.patch"
