CPPFLAGS += "-I${STAGING_INCDIR}/serf-1"
BUILD_CPPFLAGS += "-I${STAGING_INCDIR}/serf-1"
