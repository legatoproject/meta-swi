FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += " file://pseudo-glibc-rtld-next-workaround.patch"
