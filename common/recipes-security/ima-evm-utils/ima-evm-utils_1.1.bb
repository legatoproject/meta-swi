#Tag 1.1
SRC_URI[md5sum] = "77455aeee54fdc7a70c733bcb65d33cc"
SRC_URI[sha256sum] = "766b9d5f18e4c929ffd59f262a1a178aeceba9a23dd3186e3f5b57c6965f3c44"

require ima-evm-utils.inc

