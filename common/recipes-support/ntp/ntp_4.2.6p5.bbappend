FILESEXTRAPATHS_prepend := "${THISDIR}/files"

SRC_URI += "file://CVE-2014-9293.patch \
           file://CVE-2014-9296.patch \
           file://CVE-2014-9294.patch \
           file://CVE-2014-9295.patch \
           file://CVE-2014-9297.patch \
           file://CVE-2014-9298.patch \
"
