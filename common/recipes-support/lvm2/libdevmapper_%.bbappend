lvm2_%.bbappend