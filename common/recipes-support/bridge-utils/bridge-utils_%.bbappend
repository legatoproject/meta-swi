FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "\
	file://kernel-headers_fix_in6_duplication.patch \
"
