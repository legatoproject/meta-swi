EXTRA_OECONF += " --disable-doc"

