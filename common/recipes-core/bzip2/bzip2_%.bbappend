ALTERNATIVE_${PN} =+ " bzip2"
