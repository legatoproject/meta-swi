FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

INITSCRIPT_PARAMS = "start 20 S . stop 80 S ."
