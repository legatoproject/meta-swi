FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://glibc-cve-2015-7547.patch \
"

