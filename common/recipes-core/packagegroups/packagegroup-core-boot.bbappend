VIRTUAL-RUNTIME_dev_manager = "busybox"
VIRTUAL-RUNTIME_init_manager = "busybox"
