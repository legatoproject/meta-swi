RDEPENDS_${PN} += "libgcov-dev"
RDEPENDS_${PN} += "libcap-ng-dev"

