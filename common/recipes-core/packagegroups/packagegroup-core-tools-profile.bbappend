RRECOMMENDS:${PN}:remove = "perf"
RDEPENDS:${PN}:remove = "lttng-modules"
