# look for files in the layer first
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

