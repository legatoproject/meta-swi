EXTRA_OECONF_remove = " --with-system-socket=/run/dbus/system_bus_socket"
