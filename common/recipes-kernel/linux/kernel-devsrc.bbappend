# Workaround issue that nothing provides /usr/bin/awk
RDEPENDS_${PN} += " gawk"
