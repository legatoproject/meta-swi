FILESEXTRAPATHS_prepend := "${THISDIR}/${P}:"

SRC_URI += "file://CVE-2014-0160.patch"
