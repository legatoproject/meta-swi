FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://5000-de-bash-scripts.patch"
