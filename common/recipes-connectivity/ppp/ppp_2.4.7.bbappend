FILESEXTRAPATHS_prepend := "${THISDIR}/ppp:"

SRC_URI += " file://CVE-2020-8597.patch \
           "
