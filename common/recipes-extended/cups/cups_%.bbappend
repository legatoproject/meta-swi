DEPENDS_remove = "gnutls"
PACKAGECONFIG_append = "ssl"