DEPENDS_remove = "gnutls"
RDEPENDS_{PN}_remove = "gnutls"

