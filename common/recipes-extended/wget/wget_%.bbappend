DEPENDS:remove = "gnutls"
PACKAGECONFIG:append = "ssl"
