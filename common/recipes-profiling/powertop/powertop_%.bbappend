FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://posix-path-max-not-defined.patch"
