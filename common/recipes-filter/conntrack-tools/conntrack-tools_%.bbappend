# Install setcap into rootfs's recipe-sysroot-native
PACKAGE_WRITE_DEPS:append = " libcap-native"

