
# Tag LNX.LE.5.1-66221-9x40
SRCREV = "1d20f2daf86685a8a2ff5aef92d7d46a931f7462"
SYSTEMCORE_REPO = "git://codeaurora.org/platform/system/core;branch=LNX.LE.5.1_rb1.10"
