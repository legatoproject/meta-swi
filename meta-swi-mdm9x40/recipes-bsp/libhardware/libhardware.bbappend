# Tag LNX.LE.5.3-76267-9x40
SRCREV = "f42816581d8b8741117d1a522c967b6d9e15ef27"
LIBHARDWARE_REPO = "git://codeaurora.org/platform/hardware/libhardware;branch=LNX.LE.5.3"
