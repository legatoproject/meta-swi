# Tag LNX.LE.5.1-66215-9x40
SRCREV = "7778e772555650c3f749909ea1457120038c76a2"
LIBHARDWARE_REPO = "git://codeaurora.org/platform/hardware/libhardware;branch=LNX.LE.5.1_rb1.6"
