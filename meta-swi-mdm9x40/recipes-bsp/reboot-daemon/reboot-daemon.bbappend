
# Tag LNX.LE.5.1-66221-9x40
SRCREV = "d04220ee2b1b46e19369137117bf82cd92e5420a"
REBOOTD_REPO = "git://codeaurora.org/quic/le/mdm/reboot-daemon;branch=LNX.LE.5.1_rb1.10"
