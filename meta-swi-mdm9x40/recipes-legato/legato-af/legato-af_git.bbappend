DEPENDS += "loc-api"
