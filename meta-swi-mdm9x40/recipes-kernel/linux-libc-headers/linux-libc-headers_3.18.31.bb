KORG_ARCHIVE_COMPRESSION = "xz"

require recipes-kernel/linux-libc-headers/linux-libc-headers.inc

SRC_URI[md5sum] = "4a54e6572e49e040b38e3ea7bcdec1ff"
SRC_URI[sha256sum] = "0d04f979da76afb37af164b57aef8a2499b8987979d6f01adaa9b11821bf60b7"

