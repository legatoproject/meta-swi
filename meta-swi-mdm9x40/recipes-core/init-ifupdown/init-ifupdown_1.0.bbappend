# Look at this directory first.
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

INITSCRIPT_PARAMS = "start 40 S . stop 60 S ."