TARGET_NAME = "EM77XX"
