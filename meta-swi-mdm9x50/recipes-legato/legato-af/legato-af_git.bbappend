DEPENDS += "loc-hal"
