DEPENDS_remove += "alsa-intf"
DEPENDS_remove += "sierra"
