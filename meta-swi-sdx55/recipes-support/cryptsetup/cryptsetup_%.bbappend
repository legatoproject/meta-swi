PACKAGECONFIG_append = " gcrypt"
