# Remove IMA related packages
RDEPENDS_${PN}_remove = "ima-evm-utils keyutils"
