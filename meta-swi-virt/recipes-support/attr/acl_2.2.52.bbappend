# Workaround to remove dependency on bash
RDEPENDS_${PN}-ptest = "coreutils perl perl-module-filehandle perl-module-getopt-std perl-module-posix shadow"
