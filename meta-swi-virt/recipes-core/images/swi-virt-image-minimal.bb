require swi-virt-image.inc
