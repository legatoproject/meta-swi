# Add mkfs.ext*
RDEPENDS_${PN} += "e2fsprogs"
